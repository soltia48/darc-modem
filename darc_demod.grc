options:
  parameters:
    author: soltia48
    copyright: Copyright (c) 2023 soltia48
    description: Data Radio Channel (DARC) demodulator
    generate_options: no_gui
    id: darc_demod
    output_language: python
    title: DARC Demodulator
  states: {}

blocks:
- name: darc_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 8e3
    gain: '1.0'
    samp_rate: wbfm_sampling_rate
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: darc_sampling_rate
  id: variable
  parameters:
    value: 512e3
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 76.1e6
    step: 0.1e6
    stop: 94.9e6
    value: 82.5e6
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: 82.5e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0.0'
    step: '0.1'
    stop: '64.0'
    value: '12.5'
  states: {state: disabled}
- name: samples_per_symbol
  id: variable
  parameters:
    value: int(darc_sampling_rate/symbols_per_second)
  states: {}
- name: source_sampling_rate
  id: variable
  parameters:
    value: int(8e6)
  states: {state: disabled}
- name: source_sampling_rate
  id: variable
  parameters:
    value: int(1.024e6)
  states: {}
- name: symbols_per_second
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: wbfm_bandwidth
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: wbfm_deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: wbfm_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: wbfm_bandwidth
    gain: '1.0'
    samp_rate: source_sampling_rate
    width: wbfm_bandwidth*0.5
    win: window.WIN_BLACKMAN
  states: {}
- name: wbfm_sampling_rate
  id: variable
  parameters:
    value: 512e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: wbfm_sampling_rate/(2*math.pi*wbfm_deviation)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.025'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samples_per_symbol)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 76e3
    decim: int(wbfm_sampling_rate/darc_sampling_rate)
    samp_rate: wbfm_sampling_rate
    taps: darc_low_pass_filter_taps
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 0.25e6
    decim: int(source_sampling_rate/wbfm_sampling_rate)
    samp_rate: source_sampling_rate
    taps: wbfm_low_pass_filter_taps
    type: ccf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp=192.168.1.144:1234,bias=1"'
    bb_gain0: '20'
    freq0: frequency-0.25e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: source_sampling_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: wbfm_sampling_rate
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    norm_window: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: wbfm_sampling_rate
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: darc_sampling_rate
    fc: 76e3
    fftsize: '32768'
    type: complex
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    ncols: '288'
    nrows: '256'
    samp_rate: 16e3
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    ant0: RX
    args: '"rtl_tcp=192.168.1.144:1234,bias=1"'
    bb_gain0: '20.0'
    bw0: source_sampling_rate
    corr0: '-5'
    freq0: frequency-0.25e6
    gain0: '125'
    gain_mode0: 'False'
    if_gain0: '20.0'
    sample_rate: source_sampling_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: frequency-0.25e6
    gain: '40'
    samp_rate: source_sampling_rate
    type: fc32
    vga: '62'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bias: 'True'
    center_freq: frequency-0.25e6
    gain: gain
    samp_rate: source_sampling_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_demod_0, '0', qtgui_time_raster_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gmsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
